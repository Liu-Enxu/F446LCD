# Keil uVision project F446LCD.uvprojx, settings and files
target Target_1 (5060960::V5.06 update 7 (build 960)::.\ARMCCv506u7)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: F446LCD +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F446xx,USE_STDPERIPH_DRIVER
  c misc: --info sizes --info totals --info stack
  c include: ..\CORE;..\USER;..\STM32F4xx_FWLib\inc;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\TIMER;..\HARDWARE\SPI;..\HARDWARE\SD;..\HARDWARE\ADC;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\MALLOC;..\FATFS\exfuns;..\FATFS\src;..\FATFS\src\option;..\PICS;..\APP;..\APP\ui;..\LVGL;..\LVGL\lvgl\examples\porting;..\LVGL\lvgl\src\core;..\LVGL\lvgl\src\draw;..\LVGL\lvgl\src\draw\sdl;..\LVGL\lvgl\src\draw\stm32_dma2d;..\LVGL\lvgl\src\draw\sw;..\LVGL\lvgl\src\extra;..\LVGL\lvgl\src\extra\layouts;..\LVGL\lvgl\src\extra\layouts\flex;..\LVGL\lvgl\src\extra\layouts\grid;..\LVGL\lvgl\src\extra\libs;..\LVGL\lvgl\src\extra\libs\bmp;..\LVGL\lvgl\src\extra\libs\ffmpeg;..\LVGL\lvgl\src\extra\libs\freetype;..\LVGL\lvgl\src\extra\libs\fsdrv;..\LVGL\lvgl\src\extra\libs\gif;..\LVGL\lvgl\src\extra\libs\png;..\LVGL\lvgl\src\extra\libs\qrcode;..\LVGL\lvgl\src\extra\libs\rlottie;..\LVGL\lvgl\src\extra\libs\sjpg;..\LVGL\lvgl\src\extra\libs\tiny_ttf;..\LVGL\lvgl\src\extra\others;..\LVGL\lvgl\src\extra\others\gridnav;..\LVGL\lvgl\src\extra\others\monkey;..\LVGL\lvgl\src\extra\others\snapshot;..\LVGL\lvgl\src\extra\themes;..\LVGL\lvgl\src\extra\themes\basic;..\LVGL\lvgl\src\extra\themes\default;..\LVGL\lvgl\src\extra\themes\mono;..\LVGL\lvgl\src\extra\widgets;..\LVGL\lvgl\src\extra\widgets\animimg;..\LVGL\lvgl\src\extra\widgets\calendar;..\LVGL\lvgl\src\extra\widgets\chart;..\LVGL\lvgl\src\extra\widgets\colorwheel;..\LVGL\lvgl\src\extra\widgets\imgbtn;..\LVGL\lvgl\src\extra\widgets\keyboard;..\LVGL\lvgl\src\extra\widgets\led;..\LVGL\lvgl\src\extra\widgets\list;..\LVGL\lvgl\src\extra\widgets\menu;..\LVGL\lvgl\src\extra\widgets\meter;..\LVGL\lvgl\src\extra\widgets\msgbox;..\LVGL\lvgl\src\extra\widgets\span;..\LVGL\lvgl\src\extra\widgets\spinbox;..\LVGL\lvgl\src\extra\widgets\spinner;..\LVGL\lvgl\src\extra\widgets\tabview;..\LVGL\lvgl\src\extra\widgets\tileview;..\LVGL\lvgl\src\extra\widgets\win;..\LVGL\lvgl\src\font;..\LVGL\lvgl\src\hal;..\LVGL\lvgl\src\misc;..\LVGL\lvgl\src\widgets;..\FREERTOS\include;..\FREERTOS\portable\RVDS\ARM_CM4F;..\FREERTOS;..\LVGL\lvgl\demos
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group CORE
    ../CORE/: startup_stm32f446xx.s
  group FWLIB
    ../STM32F4xx_FWLib/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/SD/: sd.c
    ../HARDWARE/ADC/: adc.c
  group MALLOC
    ../MALLOC/: malloc.c
  group FATFS
    ../FATFS/src/: diskio.c ff.c
    ../FATFS/exfuns/: exfuns.c
    ../FATFS/src/option/: cc936.c
  group PICS
    ../PICS/: bmp.c gif.c piclib.c tjpgd.c
  group APP
    ../APP/: fatsd.c touch.c
    ../APP/ui/: ui.c screens.c
    ../LVGL/lvgl/demos/stress/: lv_demo_stress.c
  group LVGL/example/porting
    ../LVGL/lvgl/examples/porting/: lv_port_disp_template.c lv_port_indev_template.c
  group LVGL/src/core
    ../LVGL/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group LVGL/src/draw
    ../LVGL/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../LVGL/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
  group LVGL/src/extra
    ../LVGL/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../LVGL/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../LVGL/lvgl/src/extra/libs/bmp/: lv_bmp.c
    ../LVGL/lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../LVGL/lvgl/src/extra/libs/freetype/: lv_freetype.c
    ../LVGL/lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../LVGL/lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../LVGL/lvgl/src/extra/libs/png/: lodepng.c lv_png.c
    ../LVGL/lvgl/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../LVGL/lvgl/src/extra/libs/rlottie/: lv_rlottie.c
    ../LVGL/lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../LVGL/lvgl/src/extra/libs/tiny_ttf/: lv_tiny_ttf.c
    ../LVGL/lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ../LVGL/lvgl/src/extra/others/monkey/: lv_monkey.c
    ../LVGL/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ../LVGL/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../LVGL/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../LVGL/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../LVGL/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../LVGL/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../LVGL/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../LVGL/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../LVGL/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../LVGL/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../LVGL/lvgl/src/extra/widgets/led/: lv_led.c
    ../LVGL/lvgl/src/extra/widgets/list/: lv_list.c
    ../LVGL/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../LVGL/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../LVGL/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../LVGL/lvgl/src/extra/widgets/span/: lv_span.c
    ../LVGL/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../LVGL/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../LVGL/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../LVGL/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../LVGL/lvgl/src/extra/widgets/win/: lv_win.c
    ../LVGL/lvgl/src/extra/: lv_extra.c
  group LVGL/src/font
    ../LVGL/lvgl/src/font/: lv_font.c lv_font_montserrat_22.c lv_font_montserrat_48.c lv_font_fmt_txt.c lv_font_loader.c
  group LVGL/src/gpu
    ../LVGL/lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ../LVGL/lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
  group LVGL/src/hal
    ../LVGL/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group LVGL/src/misc
    ../LVGL/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group LVGL/src/widgets
    ../LVGL/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group FREERTOS_CORE
    ../FREERTOS/: list.c queue.c tasks.c croutine.c event_groups.c stream_buffer.c timers.c
  group FREERTOS_PORT
    ../FREERTOS/portable/MemMang/: heap_4.c
    ../FREERTOS/portable/RVDS/ARM_CM4F/: port.c
